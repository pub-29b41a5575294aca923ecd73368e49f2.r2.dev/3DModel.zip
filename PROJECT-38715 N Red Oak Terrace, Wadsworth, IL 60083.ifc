Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Elements to export: Selected elements only], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: All], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: C:\ALL\WORK\Projects\232\PROJECT-38715 N Red Oak Terrace, Wadsworth, IL 60083.ifc
Time: 2026-05-28T13:13:18
Author: Architect
Organization: TRACY A. STONE ARCHITECT
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD 25.0.0 RUS FULL Windows version (IFC add-on version: 4013 RUS FULL).
Authorization: The authorising person

# IfcSite, Местность
RefLatitude: 34, 4, 0, 0; RefLongitude: -118, -15, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, 1st Floor
In: Здание
Elevation: 0 mm

# IfcBuildingElementProxy: Brick 230, СТН-029
In: 1st Floor
Material: Brick
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Door with 2 Sidelights 25, ДВ-006
In: 1st Floor
AC_Pset_RenovationAndPhasing - Renovation Status: New
